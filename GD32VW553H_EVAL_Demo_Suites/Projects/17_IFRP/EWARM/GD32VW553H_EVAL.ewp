# IAR project GD32VW553H_EVAL.ewp, settings and files
configuration GD32VW55x (RISCV, debug)
  General.GDeviceSelect: GD32VW553xM GD GD32VW553xM
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDiagSuppress: Pe550
  ICCRISCV.CCIncludePath2: ..\..\..\..\GD32VW55x_Firmware_Library\GD32VW55x_standard_peripheral\Include; ..\..\..\..\GD32VW55x_Firmware_Library\GD32VW55x_standard_peripheral; ..\..\..\Utilities; ..\..\..\..\GD32VW55x_Firmware_Library\RISCV\env_IAR; ..\..\..\..\GD32VW55x_Firmware_Library\RISCV\drivers; ..\..\..\..\GD32VW55x_Firmware_Library\RISCV\stubs; ..; ..\Soft_Drive
  OBJCOPY.OOCOutputFile: GD32VW553H_EVAL.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32vw55x_it.c main.c systick.c
  group Doc
    ../: readme.txt
  group GD32VW55x_EVAL
    ../../../Utilities/: gd32vw553h_eval.c
  group GD32VW55x_Peripherals
    ../../../../GD32VW55x_Firmware_Library/GD32VW55x_standard_peripheral/: system_gd32vw55x.c
  group GD32VW55x_Peripherals/Source
    ../../../../GD32VW55x_Firmware_Library/GD32VW55x_standard_peripheral/Source/: gd32vw55x_adc.c gd32vw55x_cau.c gd32vw55x_cau_aes.c gd32vw55x_cau_des.c gd32vw55x_cau_tdes.c gd32vw55x_crc.c gd32vw55x_dbg.c gd32vw55x_dma.c gd32vw55x_eclic.c gd32vw55x_efuse.c gd32vw55x_exti.c gd32vw55x_fmc.c gd32vw55x_fwdgt.c gd32vw55x_gpio.c gd32vw55x_hau.c gd32vw55x_hau_sha_md5.c gd32vw55x_i2c.c gd32vw55x_pkcau.c gd32vw55x_pmu.c gd32vw55x_qspi.c gd32vw55x_rcu.c gd32vw55x_rtc.c gd32vw55x_spi.c gd32vw55x_syscfg.c gd32vw55x_timer.c gd32vw55x_trng.c gd32vw55x_usart.c gd32vw55x_wwdgt.c
  group RISCV/env_IAR
    ../../../../GD32VW55x_Firmware_Library/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../../../GD32VW55x_Firmware_Library/RISCV/stubs/: write.c
  group Soft_Drive
    ../Soft_Drive/: rc5_decode.c rc5_encode.c
